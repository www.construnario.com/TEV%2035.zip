Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: C:\Users\Usuario\Desktop\JOMBAR\MUESTRAS B.I.M\BIM\TEV 35.ifc
Time: 2017-01-10T17:34:47
Written by: ACCA_IFC.dll Version 200
Made in: Edificius 8.00c

# IfcSite, Default Site
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey (4)
In: Default Building
Name | Elevation (mm) | NominalHeight (mm)
TERRENO | -1500 | 1000
Cimentación | -500 | 500
Planta Baja | 0 | 3200
Cubierta | 3200 | 0

# IfcFurnishingElement: SEPARADOR, TEV035
In: Planta Baja
Description: TEV (SERPENTIS); Material: Color_01
PROPIEDADES TÉRMICAS - TEMPERATURA H.D.T.: 74º C (ISO 75/B)
PROPIEDADES GENERALES - DENSIDAD: 905 Kg/m3 (ISO 1183); TEMPERATURA MÁXIMA ALMACENAMIENTO: 60º C; RESISTENCIA QUÍMICA: ÁCIDOS, ÁLCALIS Y DISOLVENTES; RADIACIÓN ULTRAVIOLETA: BUENO; COLOR STANDARD: GRIS; COMPOSICIÓN: POLIPROPILENO; PESO POR UNIDAD: 64 g
Pset_ManufacturerTypeInformation - ArticleNumber: TEV (SERPENTIS); ModelReference: TEV035; ModelLabel: TEV035 (COMPATIBLE CON VE050-VE0100); Manufacturer: JOMBAR; ProductionYear: 2017
PROPIEDADES MECÁNICAS - MÓDULO ELÁSTICO EN FLEXIÓN: 1100 MPa (ISO 178); RESISTENCIA AL IMPACTO CHARPY (23º CON ENTALLA): 12 KJ/m2 (ISO 179); IMPACTO IZOD (23º CON MUESCA): 11 KJ/m2 (ISO 180); IMPACTO IZOD (-20º SIN MUESCA): 60 KJ/m2 (ISO 527-1); DUREZA SHORE D: 60 ESCALA D (ISO 868); CARGA MÁXIMA POR PIEZA: 100 Kg
